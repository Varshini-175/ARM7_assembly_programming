# Keil uVision project Basic_programming.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Basic_programming
  c flags: Optim=1
  group Source Group 1
    ./: Add_array.asm
